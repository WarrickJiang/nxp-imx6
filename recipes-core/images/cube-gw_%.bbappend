#Moved from bsp-pkg.inc
IMAGE_INSTALL += "i2c-tools"
IMAGE_INSTALL += "canutils"
IMAGE_INSTALL += "pm-utils"
IMAGE_INSTALL += "alsa-utils"
IMAGE_INSTALL += "mtdev"

#Customer required
IMAGE_INSTALL += "libmodbus"
IMAGE_INSTALL += "nodejs"

IMAGE_INSTALL += "upgrade-mgr"
