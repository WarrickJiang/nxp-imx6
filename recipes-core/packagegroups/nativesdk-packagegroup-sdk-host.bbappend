RDEPENDS_${PN} += " \
	nativesdk-ostree-deploy \
"
